<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>blocks_null</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_nop</key>
<param><key>id</key><value>blocks_nop_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_nop_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nop_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
